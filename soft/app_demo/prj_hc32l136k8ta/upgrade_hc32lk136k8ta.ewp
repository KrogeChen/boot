# IAR project upgrade_hc32lk136k8ta.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L136K8TA HDSC HC32L136K8TA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; lib_hc32l13x\common; lib_hc32l13x\driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: upgrade_hc32lk136k8ta.out
  ILINK.IlinkIcfFile: hc32l13x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: upgrade_hc32lk136k8ta.bin
  ILINK.IlinkIcfFile: app_hc32l13x.icf
  group app
    ../app/: app_cfg.h app_general.c app_general.h app_upgrade_easy.c app_upgrade_easy.h main.c
  group mde/mde_bough_link
    ../mde/mde_bough_link/: mde_bough_link_half.c mde_bough_link_half.h solid_bough_link_half.h
  group mde/mde_bough_link/depend
    ../mde/mde_bough_link/depend/: bsp_bough_link.c bsp_bough_link.h
  group mde/mde_led_blink
    ../mde/mde_led_blink/: mde_led_blink.c mde_led_blink.h
  group mde/mde_led_blink/depend
    ../mde/mde_led_blink/depend/: bsp_led_blink.c bsp_led_blink.h
  group mde/mde_random
    ../mde/mde_random/: mde_random.c mde_random.h
  group mde/mde_random/depend
    ../mde/mde_random/depend/: bsp_random.c bsp_random.h
  group mde/mde_sys_clock
    ../mde/mde_sys_clock/: mde_system_clock.c mde_system_clock.h
  group mde/mde_sys_clock/depend
    ../mde/mde_sys_clock/depend/: bsp_system_clock.c bsp_system_clock.h
  group mde/mde_upgradeFiles
    ../mde/mde_upgradeFiles/: mde_upgradeFiles.c mde_upgradeFiles.h
  group mde/mde_upgradeFiles/depend
    ../mde/mde_upgradeFiles/depend/: bsp_upgradeFiles.c bsp_upgradeFiles.h
  group mde/mde_watchdog
    ../mde/mde_watchdog/: mde_watchdog.c mde_watchdog.h
  group mde/mde_watchdog/depend
    ../mde/mde_watchdog/depend/: bsp_watchdog.c bsp_watchdog.h
  group pbc/pbc_crc16
    ../pbc/pbc_crc16/: pbc_crc16.c pbc_crc16.h
  group pbc/pbc_dataConvert
    ../pbc/pbc_dataConvert/: pbc_dataConvert.c
  group pbc/pbc_lib
    ./: startup_hc32l13x.s
  group pbc/pbc_lib/common
    lib_hc32l13x/common/: interrupts_hc32l13x.c system_hc32l13x.c
  group pbc/pbc_sysTick
    ../pbc/pbc_sysTick/: pbc_sysTick.c pbc_sysTick.h
  group pbc/pbc_sysTick/depend
    ../pbc/pbc_sysTick/depend/: bsp_sysTick.c bsp_sysTick.h
